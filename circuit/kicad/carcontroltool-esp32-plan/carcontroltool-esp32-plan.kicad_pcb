# Repository indeedphp/oscitrolka

File README.md:

# oscitrolka

Скетч для контрольки(пробника, тестера) автоэлектрика с осциллографом, частотометром, генератором шим сигнала, вольтметром с подключаемой нагрузкой, кан лин тестером и таймером(недоделан)

Видеообзор контрольки на канале ютуб "Автоэлектрика онлайн" по ссылке https://www.youtube.com/watch?v=iU-zxOGDLu8

Сайт по контрольке со схемамами и пр. https://indeedphp.github.io/arduino/pages/handiwork.html

Телеграм канал по обсуждентю контрольки и про автоэлектрику от канала ютуб "Автоэлектрика онлайн"  https://t.me/+kgjzf6Xn2m0yOWIy

## KiCad design circuit/kicad/carcontroltool-esp32-plan/carcontroltool-esp32-plan.kicad_pcb

File circuit/kicad/carcontroltool-esp32-plan/README.md:

Схему можно увидеть в [carcontroltool-esp32-plan.pdf](carcontroltool-esp32-plan.pdf)

Для любителей ЛУТ проекция Top [carcontroltool-esp32-LUT-Top(normal).pdf](carcontroltool-esp32-LUT-Top(normal).pdf)
и Bottom(зеркальное)[carcontroltool-esp32-LUT-Bottom(miror).pdf](carcontroltool-esp32-LUT-Bottom(miror).pdf)

В файле carcontroltool-esp32-plan.step имеется модель для CAD, которую можно использовать для создания собственного корпуса устройства.
Платп состоит из двух частей. В файле

[carcontroltool-esp32-model-CutCarControllTool-esp32-Right.stl](../../cad/carcontroltool-esp32/carcontroltool-esp32-model-CutCarControllTool-esp32-Right.stl)

[carcontroltool-esp32-model-CutCarControlTool-Esp32-Left.stl](../../cad/carcontroltool-esp32/carcontroltool-esp32-model-CutCarControlTool-Esp32-Left.stl)

находится трехмерные модели обеих плат.

Схему можно посмотреть в файле [carcontroltool-esp32-plan.csv](carcontroltool-esp32-plan.csv)

Добавлен светодиод для подсветки. Управление должно идти через меню.

Добавлен транзистор на активацию пищалки: увы, 10мА с пина МК недостаточно управлять пищалкой. слишком тихо.

Для исследований выложена схема аналоговй части, собраная под планарные компоненты. Это необходимо для сбора на тестоввой плате для проверки аналоговой части.Резисторы используются вертикально.

Parts:
BZ1: Buzzer_5V; MagneticBuzzer_ProSignal_ABT-410-RC
Brd1: SSD1306 128x64; SSD1306
D1: 36V0; D_5W_P10.16mm_Horizontal
D2: 3V3; D_5W_P10.16mm_Horizontal
D3: LED; LED_D5.0mm
J1, J3, J6, J7, J13, J14, J15, J16: Conn_01x01_Pin; PinSocket_1x01_P2.54mm_Vertical
J2: HW_PRG; PinHeader_1x06_P2.54mm_Vertical
J4: GROUND; Pin_D1.0mm_L10.0mm
J5: JST_02; JST_EH_B2B-EH-A_1x02_P2.50mm_Vertical
J8: PINHD_1x2_Male; PinHeader_1x02_P2.54mm_Vertical
J9, J12: PINHD_1x4_Female; PinSocket_1x04_P2.54mm_Vertical
J10: PINHD_1x2_Female; PinSocket_1x02_P2.54mm_Vertical
J11: PINHD_1x4_Male; PinHeader_1x04_P2.54mm_Vertical
J17: +; Pin_D1.0mm_L10.0mm
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
Module-TP4056: BATTERY-CHARGER-LI-PROT
Q1, Q2, Q3: AOT3400; SOT-23
Q4, Q5, Q6: AO3400A; SOT-23
R1: 100; R_2512_6332Metric
R2: 5k; R_0805_2012Metric
R3, R6: 100K; R_0805_2012Metric
R4: 50K; R_0805_2012Metric
R5, R7, R8, R9, R10, R11, R12, R13: 10K; R_0805_2012Metric
R14, R15, R16, R17, R23, R24: 100; R_0805_2012Metric
R18: 350k; R_0805_2012Metric
R19, R20, R22: 10k; R_0805_2012Metric
R21: 30k; R_0805_2012Metric
S1: SW_SPDT_PCM12
SW1, SW2, SW3, SW4: Push_Button; SW_PUSH_6mm_H4.3mm
U1: ESP32-WROOM-32; ESP32-WROOM-32UE
U2: TL431LP; TO-92_Inline
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
DSP_SCK: Brd1.3 (SCL), J9.3, U1.12 (IO27)
DSP_SDA: Brd1.4 (SDA), J9.4, U1.11 (IO26)
ESP_IO0: J2.2, R11.1, U1.25 (IO0)
ESP_RES: J2.6, R13.2, U1.3 (EN)
ESP_RX: J2.3, U1.34 (RXD0/IO3)
ESP_TX: J2.4, U1.35 (TXD0/IO1)
GND: D1.2 (A), D2.2 (A), J2.5, J4.1, J8.2, J10.2, JP1.3 (B), JP2.1 (A), Module-TP4056.OUT-, Q1.1 (S), Q2.1 (S), Q3.1 (S), R3.1, R4.2, R5.1, R19.2, R20.2, R22.1, SW1.1, SW2.1, SW3.1, SW4.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (A), U3.1 (GND)
Key1: J11.1, J12.1, R8.2, SW1.2, U1.27 (IO16)
Key2: J11.2, J12.2, R10.2, SW3.2, U1.28 (IO17)
Key3: J11.4, J12.4, R9.2, SW2.2, U1.31 (IO19)
Key4: J11.3, J12.3, R12.2, SW4.2, U1.30 (IO18)
MC_A7: D2.1 (K), Q4.2 (S), Q6.3 (D), R5.2, R6.1, R19.1, U1.4 (SENSOR_VP)
MC_D9: R15.2, U1.16 (IO13)
MC_LIGNT: R16.2, U1.13 (IO14)
MC_REF: R7.2, U1.26 (IO4), U2.3 (K)
MK_BUZZ: R14.2, U1.33 (IO21)
unnamed: Brd1.1 (GND), J9.1, JP2.2 (C)
unnamed: Brd1.2 (VCC), J9.2, JP1.2 (C)
unnamed: D1.1 (K), R2.1, R3.2, U2.1 (REF)
unnamed: D3.1 (K), R17.1
unnamed: J5.2, Module-TP4056.B-
unnamed: Q1.3 (D), R17.2
unnamed: Q1.2 (G), R16.1
unnamed: Q2.3 (D), R1.1
unnamed: Q2.2 (G), R4.1, R15.1
unnamed: BZ1.2, Q3.3 (D)
unnamed: Q3.2 (G), R14.1
unnamed: Q4.3 (D), R18.2
unnamed: Q4.1 (G), R20.1, R24.1
unnamed: Q5.1 (G), Q6.1 (G), R22.2, R23.1
unnamed: Q5.2 (S), Q6.2 (S), R21.1
unnamed: Module-TP4056.B+, S1.1 (O)
unnamed: J5.1, S1.2
OM_EN: R23.2
SHUNT: J1.1, J3.1, J6.1, J7.1, J13.1, J14.1, J15.1, J16.1, Q5.3 (D), R1.2, R2.2, R6.2, R18.1
VCC: BZ1.1, D3.2 (A), J2.1, J8.1, J10.1, J17.1, JP1.1 (A), JP2.3 (B), R7.1, R8.1, R9.1, R10.1, R11.2, R12.1, R13.1, R21.2, U1.2 (VDD), U3.2 (VO)
VM_EN: R24.2

Notes on the sheet:
* Возможность выдать по кнопке +12 вольт на иглу, выходной ток 200мА * Звуковой излучатель(пищалка) при замыкании на массу * Цифровой вольтметр 1-30В * Цифровой частотомер 0-99Hz * Светодиодный фонарик (расположен под иглой) * Генератор минусовых импульсов от 10 до 100Hz с регулируемой скоростью из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
* Q2 возможно заменить на: IRLB8743, AOT240L, DMG2302, AOT3400, IRLHM630 * R1 и R11 предусматривают большие токи и расчитаны на 1 Ватт. * Key4 - SHUNT * ESP32 ADC1_CH0 IO36 # ADC1_CH3 IO39 ADC1_CH6 IO34 # ADC1_CH7 IO35 ADC1_CH4 IO32 # ADC1_CH5 IO33 ADC2_CH8 IO25 # ADC2_CH9 IO26 ADC2_CH7 IO27 # ADC2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
DISPLAY

Board: 2 copper layers, 146.6 x 36.9 mm, 63 parts (19 on the bottom side), 35 nets.

## KiCad design circuit/kicad/carcontroltool-esp32-plan/carcontroltool-esp32-raster.kicad_pcb

Parts:
D1: 36V0; D_5W_P10.16mm_Horizontal
D2: 3V3; D_5W_P10.16mm_Horizontal
J2, J8: PINHD_1x2_Male; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x01_Pin; PinSocket_1x01_P2.54mm_Vertical
Q1, Q3, Q4: AO3400A; TO-92L_Inline
Q2: AOT3400; TO-92L_Inline
R1, R11, R14, R15: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R2: 5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R3, R6: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R4: 50K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R5, R7: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R8: 350k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R9, R10, R13: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R12: 30k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
U2: TL431LP; TO-92L_Inline

Connections:
GND: D1.2 (A), D2.2 (A), J8.2, Q2.1 (S), R3.1, R4.2, R5.1, R9.2, R10.2, R13.1, U2.2 (A); also elsewhere on the board
MC_A7: D2.1 (K), J2.1, Q1.2 (S), Q4.3 (D), R5.2, R6.1, R9.1
MC_D9: J2.2, R15.2
MC_REF: R7.2, U2.3 (K)
unnamed: D1.1 (K), R2.1, R3.2, U2.1 (REF)
unnamed: Q1.3 (D), R8.2
unnamed: Q1.1 (G), R10.1, R11.1
unnamed: Q2.3 (D), R1.1
unnamed: Q2.2 (G), R4.1, R15.1
unnamed: Q3.1 (G), Q4.1 (G), R13.2, R14.1
unnamed: Q3.2 (S), Q4.2 (S), R12.1
OM_EN: R14.2
SHUNT: J3.1, Q3.3 (D), R1.2, R2.2, R6.2, R8.1
VCC: J8.1, R7.1, R12.2; also elsewhere on the board
VM_EN: R11.2

Board: 2 copper layers, 137.5 x 40.8 mm, 27 parts (0 on the bottom side), 13 nets.

Other parts of the board:
J4: GROUND; Pin_D1.0mm_L10.0mm
J17: +; Pin_D1.0mm_L10.0mm

Their connections:
GND: J4.1; also elsewhere on the board
VCC: J17.1; also elsewhere on the board

## Code that names these connections

File firmware/Intertest/src/control_keypad.cpp:

#include "control_keypad.h"
#include <Arduino.h>
#include "helpers.h"
#include "buzzer.h"
#include "interface_wide.h"
#include "menu.h"
#include "pwm_item.h"
#include "light_item.h"
#include "upd_item.h"

#define BUZZ_DELAY_         100
extern int settingsVal;

#define DBGPRINTF_(x,y)   Serial.printf_P(PSTR( x ), y);

void IRAM_ATTR isr_key1change() {
    //digitalWrite( PIN_MK_BUZZ, MK_BUZZ_ACTIVE );
	Keypad.keys.as_keys.key1 = ! digitalRead(PIN_KEYPAD_KEY1);
    Keypad.time = millis();
    //digitalWrite( PIN_MK_BUZZ, MK_BUZZ_INACTIVE );
}

void IRAM_ATTR isr_key2change() {
    //digitalWrite( PIN_MK_BUZZ, MK_BUZZ_ACTIVE );
	Keypad.keys.as_keys.key2 = ! digitalRead(PIN_KEYPAD_KEY2);
    Keypad.time = millis();
    //digitalWrite( PIN_MK_BUZZ, MK_BUZZ_INACTIVE );
}

void IRAM_ATTR isr_key3change() {
    //digitalWrite( PIN_MK_BUZZ, MK_BUZZ_ACTIVE );
	Keypad.keys.as_keys.key3 = ! digitalRead(PIN_KEYPAD_KEY3);
    Keypad.time = millis();
    //digitalWrite( PIN_MK_BUZZ, MK_BUZZ_INACTIVE );
}

void control_init(){
    LastestKeypad.keys.as_int = 0x0;
    Keypad.keys.as_int = 0x0;
    //Serial.println(F("Keypad init"));
    pinMode(PIN_KEYPAD_KEY1, INPUT_PULLUP);
    attachInterrupt(PIN_KEYPAD_KEY1, isr_key1change, CHANGE);
    //Serial.println(F("kp k1 r"));

    pinMode(PIN_KEYPAD_KEY2, INPUT_PULLUP);
    attachInterrupt(PIN_KEYPAD_KEY2, isr_key2change, CHANGE);
    //Serial.println(F("kp k2 r"));

    pinMode(PIN_KEYPAD_KEY3, INPUT_PULLUP);
    attachInterrupt(PIN_KEYPAD_KEY3, isr_key3change, CHANGE);
    //Serial.println(F("kp k3 r"));

    pinMode(PIN_KEYPAD_KEYSHUNT, INPUT_PULLUP);
}

void control_loop(){
    
    if ( Keypad.keys.as_int != LastestKeypad.keys.as_int)
    {

        //Serial.printf_P(PSTR("Keypad:L" BYTE_TO_BINARY_PATTERN ">:K"), BYTE_TO_BINARY(LastestKeypad.as_int) );
        //Serial.printf_P(PSTR(BYTE_TO_BINARY_PATTERN "\r\n"), BYTE_TO_BINARY(Keypad.as_int) );

        
        //Serial.printf_P(PSTR("isKey2pressed():%d\r\n"), isKey2pressed());
        /*
        Serial.printf_P(PSTR("isKey2PressedKey1freed():%d\r\n"), isKey2PressedKey1freed());
        Serial.printf_P(PSTR("isKey2PressedKey3freed():%d\r\n"), isKey2PressedKey3freed());

        Serial.printf_P(PSTR("isKey1freedWithoutKey2():%d\r\n"), isKey1freedWithoutKey2());
        Serial.printf_P(PSTR("isKey3freedWithoutKey2():%d\r\n"), isKey3freedWithoutKey2());

        Serial.printf_P(PSTR("1_menu_current_positon:%d\r\n"), menu_current_positon);
        */

        int mcp = menu_current_positon;

        // movement between top menu items +
        if ( 
                (Keypad.keys.as_int == KEYS1ONLY_)
              & (LastestKeypad.keys.as_int == KEYSNONE_)
              & (! is_menu_selected)
           ){
            menu_current_positon++;
            is_menu_selected = false;
            //DBGPRINTF_("+menu_current_positon\r\n",menu_current_positon);
        }
        //*

        // movement between top menu items -
        if ( 
                (Keypad.keys.as_int == KEYS3ONLY_)
              & (LastestKeypad.keys.as_int == KEYSNONE_)
              & (! is_menu_selected)
           ){
            menu_current_positon--;
            is_menu_selected = false;
            //DBGPRINTF_("-menu_current_positon\r\n",menu_current_positon);
        }
        //*

        if ( menu_current_positon > MENU_LASTLIDX_ )
            menu_current_positon = 0;
        if ( menu_current_positon < 0 )
            menu_current_positon = MENU_LASTLIDX_;

        //Serial.printf_P(PSTR("menu_current_positon:%d "), menu_current_positon);
        //Serial.printf_P(PSTR("mcp:%d\r\n"), mcp);
        if ( menu_current_positon != mcp ){ //the position was changed

            //Serial.println(F("menu_current_positon != mcp"));
            is_menu_selected = false;
            stop_pwm();
            display_currentmenu();
        }

        //*****************************************************************

        if ( //check if Key2 pressed
                (Keypad.keys.as_int == KEYSNONE_)
              & (LastestKeypad.keys.as_int == KEYS2ONLY_)
           )
        {
            is_menu_selected = ! is_menu_selected;

            if ( ! is_menu_selected ) {

                int32_t buffer[BUFFER_LENGTH];

                Serial.print(F("sel:"));
                switch( menu_current_positon ){
                    case MENU_IDX_VOLT_:
                        //Serial.println(F("select VOLT"));
                        voltmetr.setAdcChars(adc_chars);
                        display_voltmetr_init();
                        break;

                    case MENU_IDX_OSC_:
                        //Serial.println(F("select OSC"));
                        voltmetr.setAdcChars(adc_chars);
                        break;

                    case MENU_IDX_PWM_:
                        //Serial.println(F("select PWM"));
                        start_pwm( pwm_freq, pwm_duty_cycle );
                        break;

                    case MENU_IDX_SHUNT_:
                        //Serial.println(F("select SHUNT"));
                        is_menu_selected = false;
                        pwm_once_start_stop( SHUNT_PWM_PULSE_DELAY );
                        break;    

                    case MENU_IDX_LIGHT_:
                        //Serial.println(F("select LIGHT"));
                        switch_light();
                        is_menu_selected = false;
                        break; 

                    case MENU_IDX_UPD_:
                        Serial.println(F("select UPDATE"));
                        update_init();
                        //is_menu_selected = false;
                        break;    
                         
                } //switch( menu_current_positon )
            } //if ( ! is_menu_selected)
            else {
                //Serial.println(F("not is_menu_selected"));
                display_currentmenu();
            }
        }//if Key2 pressed

        LastestKeypad.keys.as_int = Keypad.keys.as_int;

        
        
        //Serial.printf_P(PSTR("2_menu_current_positon:%d "), menu_current_positon);
        //Serial.printf_P(PSTR("is_menu_selected:%d\r\n"), is_menu_selected);
        

    
    }
    
}

## Commit log

2023-12-26 first commit1
2023-12-26 first commit2
2023-12-26 first commit3
2023-12-27 kicad
2023-12-27 display в отдельный файл. Упрощение кода дисплея.
2023-12-27 оптимизация дисплея 2
2023-12-27 изменение kiCAD схемы, добавлены пропущенные кнопки. ! пин D12 не задан на плате и перемещен на D7
2023-12-28 разветвление под ESP32. код не компилируется из-за библиотеки PWM
2023-12-28 схематика esp32 не до конца разведена. в коде не решена проблема с библиотекой PWM
2023-12-28 печатная плата под Arduino Nano разведена
2023-12-28 на PCB поменяны местами T/B. Земляной полигон на обеих стронах пустого места.
2023-12-28 PCB: добавлен шунт с кнопкой. нужно пропаивать отдельно.
2023-12-28 PCB: добавлен шунт с резистором.
2023-12-28 PCB: дорожки на МК под углом 90
2023-12-28 PCB: сигнал GROUND
2023-12-28 PCB: шунт-резистор MOSFET
2023-12-29 PCB: терминал на +. Выравнивание точек и линиц
2023-12-29 empty
2023-12-29 PCB: changes for ESP32, Display 128x64, TP4056, Buzzer, Double pannel for buttons
2023-12-30 PCB: ESP32: MC Pins for ADC
2023-12-30 PCB: ESP32: Final
2023-12-30 PCB: ESP32: sligtes corrections
2023-12-31 PCB: ESP32: correction to the pwr switch on the board
2024-01-01 firmware: отдельная версия от @Watashi Serge
2024-01-02 PCB: READ.me
2024-01-03 clearing
2024-01-04 переезд на PlatformIO
2024-01-04 changes in the circuit: MK_D9, MC_A. pwm_item.*
2024-01-05 PCB: current resistor for Gate of MOSFET. FW: some changes in menu, but does not ready
2024-01-05 PCB: LED for Light
2024-01-06 FW: menu is working. It need to make all other menu ittems.
2024-01-06 PCB: MOSFET on the control of SUMMER- 10mA in the pin is not enought to buzz. FW: menu item SHUNT. menu item LIGHT
2024-01-06 meintenance, README.md
2024-01-06 maintenance: PDFs for LUT
2024-01-06 PCB: correction with Pin 4 (ADC)
2024-01-06 FW: скоррость I2C увеличина, Показ вольтметра не правильный
2024-01-07 Update item
2024-01-13 PCB: jumpers for supply of display(for SH*)
2024-01-13 PCB: analog raster board
2024-01-28 PCB: changes with new analog; new analog in raster wiredboard
